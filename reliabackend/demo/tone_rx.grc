options:
  parameters:
    generate_options: no_gui
    id: demo_rx
    output_language: python
    title: RELIA tone spectrum demo
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: '2450'
  states: {}
- name: device_url
  id: variable
  parameters:
    value: '"192.168.3.1"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '600000'
  states: {}
- name: start_freq
  id: variable
  parameters:
    value: center_freq - samp_rate/2000000
  states: {}
- name: step
  id: variable
  parameters:
    value: samp_rate/vec_len/1000000
  states: {}
- name: stop_freq
  id: variable
  parameters:
    value: center_freq*1000000 + samp_rate/2
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: vec_len
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: vec_len
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '600000'
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: center_freq*1000000
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: device_url
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    label1: '''Receiver'''
    name: '''Received RF spectrum'''
    vlen: vec_len
    x_axis_label: '''Frequency'''
    x_start: start_freq
    x_step: step
    x_units: '''MHz'''
    y_axis_label: '''Relative power'''
    y_units: '''dB'''
    ymax: '30'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0, '0']
- [fft_vxx_0_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [iio_pluto_source_0, '0', blocks_stream_to_vector_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0
